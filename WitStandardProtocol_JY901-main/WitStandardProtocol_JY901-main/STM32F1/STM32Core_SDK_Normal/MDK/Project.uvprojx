# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Source\APP;..\Source\STM32F10xLib\inc;..\Source\STM32F10xLib\M3;..\Source\Drive;..\Source\wit_c_sdk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../Source/APP/: Main.c Main.h
    ../Source/wit_c_sdk/: REG.h wit_c_sdk.c
  group DRIVER
    ../Source/Drive/: UART2.c UART1.c delay.c delay.h DIO.h IOI2C.h REG.h UART1.h UART2.h
    ../Source/wit_c_sdk/: wit_c_sdk.h
  group FWLib
    ../Source/STM32F10xLib/M3/: system_stm32f10x.c stm32f10x_it.c
    ../Source/STM32F10xLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_pwr.c
    ../Source/STM32F10xLib/startup/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.0.1
